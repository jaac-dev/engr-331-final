# Keil uVision project ClockQuestionMark.uvprojx, settings and files
target Firmware (6230000::V6.23::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GuitarFX
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers
    ./: lcd.h lcd.c gpio.c gpio.h delay.c delay.h adc.h adc.c keypad.c keypad.h
  group Main
    ./: main.c
software components: CMSIS:CORE 6.1.1, Device:Startup 2.6.3
